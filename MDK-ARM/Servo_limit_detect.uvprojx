# Keil uVision project Servo_limit_detect.uvprojx, settings and files
target Servo_limit_detect (6230000::V6.23::ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Servo_limit_detect +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../BSP/Inc;../BSP/Src;../SEGGER_RTT;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../BSP/lvgl;../BSP/lvgl/demos;../BSP/lvgl/porting;../BSP/lvgl/src;../BSP/lvgl/demos/benchmark
  asm include: ../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group RTT
    ../SEGGER_RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group BSP
    ../BSP/Src/: ina229.c bsp_LCD_ILI9341.c bsp_XPT2046.c keys.c servo.c relay.c bsp_log.c
  group APP
    ../BSP/Src/: servo_actuator.c current.c app_lcd.c app_relay.c servo_calib.c app_servo.c machine.c
  group lvgl/src
    ../BSP/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../BSP/lvgl/src/draw/arm2d/: lv_gpu_arm2d.c
    ../BSP/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../BSP/lvgl/src/draw/nxp/pxp/: lv_draw_pxp.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ../BSP/lvgl/src/draw/nxp/vglite/: lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_line.c lv_draw_vglite_rect.c lv_vglite_buf.c lv_vglite_utils.c
    ../BSP/lvgl/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
    ../BSP/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../BSP/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../BSP/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../BSP/lvgl/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ../BSP/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../BSP/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../BSP/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../BSP/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../BSP/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../BSP/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../BSP/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../BSP/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../BSP/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../BSP/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../BSP/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../BSP/lvgl/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
    ../BSP/lvgl/src/extra/: lv_extra.c
    ../BSP/lvgl/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../BSP/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../BSP/lvgl/src/extra/others/ime/: lv_ime_pinyin.c
    ../BSP/lvgl/src/extra/others/imgfont/: lv_imgfont.c
    ../BSP/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../BSP/lvgl/src/extra/others/msg/: lv_msg.c
    ../BSP/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../BSP/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../BSP/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../BSP/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../BSP/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../BSP/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../BSP/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../BSP/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../BSP/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../BSP/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../BSP/lvgl/src/extra/widgets/led/: lv_led.c
    ../BSP/lvgl/src/extra/widgets/list/: lv_list.c
    ../BSP/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../BSP/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../BSP/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../BSP/lvgl/src/extra/widgets/span/: lv_span.c
    ../BSP/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../BSP/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../BSP/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../BSP/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../BSP/lvgl/src/extra/widgets/win/: lv_win.c
    ../BSP/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
    ../BSP/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../BSP/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../BSP/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group lvgl/porting
    ../BSP/lvgl/porting/: lv_port_disp.c lv_port_indev.c
    ../BSP/lvgl/: lv_conf.h lvgl.h
  group lvgl/demos
    ../BSP/lvgl/demos/benchmark/: lv_demo_benchmark.c
    ../BSP/lvgl/demos/keypad_encoder/: lv_demo_keypad_encoder.c
    ../BSP/lvgl/demos/music/: lv_demo_music.c lv_demo_music_list.c lv_demo_music_main.c
    ../BSP/lvgl/demos/music/assets/: img_lv_demo_music_btn_corner_large.c img_lv_demo_music_btn_list_pause.c img_lv_demo_music_btn_list_pause_large.c img_lv_demo_music_btn_list_play.c img_lv_demo_music_btn_list_play_large.c img_lv_demo_music_btn_loop.c img_lv_demo_music_btn_loop_large.c img_lv_demo_music_btn_next.c img_lv_demo_music_btn_next_large.c img_lv_demo_music_btn_pause.c img_lv_demo_music_btn_pause_large.c img_lv_demo_music_btn_play.c img_lv_demo_music_btn_play_large.c img_lv_demo_music_btn_prev.c img_lv_demo_music_btn_prev_large.c img_lv_demo_music_btn_rnd.c img_lv_demo_music_btn_rnd_large.c img_lv_demo_music_corner_left.c img_lv_demo_music_corner_left_large.c img_lv_demo_music_corner_right.c img_lv_demo_music_corner_right_large.c img_lv_demo_music_cover_1.c img_lv_demo_music_cover_1_large.c img_lv_demo_music_cover_2.c img_lv_demo_music_cover_2_large.c img_lv_demo_music_cover_3.c img_lv_demo_music_cover_3_large.c img_lv_demo_music_icon_1.c img_lv_demo_music_icon_1_large.c img_lv_demo_music_icon_2.c img_lv_demo_music_icon_2_large.c img_lv_demo_music_icon_3.c img_lv_demo_music_icon_3_large.c img_lv_demo_music_icon_4.c img_lv_demo_music_icon_4_large.c img_lv_demo_music_list_border.c img_lv_demo_music_list_border_large.c img_lv_demo_music_logo.c img_lv_demo_music_slider_knob.c img_lv_demo_music_slider_knob_large.c img_lv_demo_music_wave_bottom.c img_lv_demo_music_wave_bottom_large.c img_lv_demo_music_wave_top.c img_lv_demo_music_wave_top_large.c
    ../BSP/lvgl/demos/stress/: lv_demo_stress.c
    ../BSP/lvgl/demos/widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_lvgl_logo.c
    ../BSP/lvgl/demos/widgets/: lv_demo_widgets.c
    ../BSP/lvgl/demos/benchmark/assets/: img_benchmark_cogwheel_alpha16.c img_benchmark_cogwheel_argb.c img_benchmark_cogwheel_chroma_keyed.c img_benchmark_cogwheel_indexed16.c img_benchmark_cogwheel_rgb.c img_benchmark_cogwheel_rgb565a8.c lv_font_bechmark_montserrat_12_compr_az.c.c lv_font_bechmark_montserrat_16_compr_az.c.c lv_font_bechmark_montserrat_28_compr_az.c.c
software components: CMSIS:CORE 6.1.0
